# IAR project STM8.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x80
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\OSAL\include; ..\user
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8 Test.hex
  ILINK.IlinkOutputFile: STM8 Test.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenStackSize: 0x100
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: user; ..\OSAL\include
  OBJCOPY.OOCOutputFile: STM8 Test.srec
  group osal
    ../OSAL/osal/: osal.c osal_event.c osal_memory.c osal_msg.c osal_timer.c
    ../OSAL/hal/: timer.c
  group user
    ../user/: led.c usart.c
    ../OSAL/application/: osal_main.c serial_task.c
