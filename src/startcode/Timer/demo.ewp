# IAR project demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ; ..\..\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.srec
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group StdPeriph_Driver
    ../../STM8S_StdPeriph_Driver/src/: stm8s_gpio.c stm8s_tim4.c
  group user
    ./: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
    ../../STM8S_StdPeriph_Driver/inc/: stm8s.h
